# Keil uVision project test2.4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test2.4
  c flags: Optim=1
  c define: USE_STDPERIPPH_DRIVER
  c include: "C:\Program Files (x86)\STMicroelectronics\iNEMO Suite\Firmware\Common\STM32F10xFWLib\v3_3_0\Libraries\STM32F10x_StdPeriph_Driver\src";"C:\Program Files (x86)\STMicroelectronics\iNEMO Suite\Firmware\Common\STM32F10xFWLib\v3_3_0\Libraries\STM32F10x_StdPeriph_Driver\inc";"C:\Program Files (x86)\STMicroelectronics\iNEMO Suite\Firmware\Common\STM32F10xFWLib\v3_3_0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x";"C:\Program Files (x86)\STMicroelectronics\iNEMO Suite\Firmware\iNEMO_Project\iNEMO_Project\iNEMO_Lib";"..\test2.4"
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: STM32F10x.s main.c LSM303DLH.c stm32f10x_conf.h misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c misc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_rcc.h HAL_LSM303DLH.h LSM303DLH.h
