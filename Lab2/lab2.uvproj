# Keil uVision project lab2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lab2
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: "C:\Program Files (x86)\STMicroelectronics\iNEMO Suite\Firmware\Common\STM32F10xFWLib\v3_3_0\Libraries\STM32F10x_StdPeriph_Driver\inc";"C:\Program Files (x86)\STMicroelectronics\iNEMO Suite\Firmware\Common\STM32F10xFWLib\v3_3_0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x";"C:\Users\Akeel\McGill\Fall 2011\microP\MicroP_Shared\Lab2"
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Assembly
    ./: startup_stm32f10x_hd.s
  group Source
    ./: stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_gpio.c main.c LSM303DLH.c iNEMO_led.c acc_lib.c
  group Headers
    ./: stm32f10x_conf.h LSM303DLH.h HAL_LSM303DLH.h iNEMO_led.h acc_lib.h
